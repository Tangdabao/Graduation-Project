# Keil uVision project IIC.uvprojx, settings and files
target IIC (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IIC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\USMART;..\APP\IIC;..\APP\IQS263;..\APP\KEY;..\APP\LED;..\APP\LP55231;..\APP\OLED;..\APP\RTC;..\APP\BEEP;..\APP\DS18B20;..\APP\AT24C256;..\APP\DHT11;..\APP\TimerDH11;..\APP\Standby
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group APP
    ../APP/IIC/: myiic.c
    ../APP/IQS263/: IQS263.c
    ../APP/KEY/: key.c
    ../APP/LED/: led.c
    ../APP/LP55231/: LP55231.c
    ../APP/OLED/: oled.c
    ../APP/RTC/: rtc.c
    ../APP/BEEP/: beep.c
    ../APP/DS18B20/: ds18b20.c
    ../APP/AT24C256/: at24c256.c
    ../APP/DHT11/: dht11.c
    ../APP/TimerDH11/: timerdh11.c
    ../APP/Standby/: Standby.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_exti.c
  group README
    ../: README.TXT
